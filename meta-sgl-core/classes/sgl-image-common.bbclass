# This class defines common image features or other
# configurations to be shared by many images
# in meta-sgl

FEATURE_PACKAGES_zeroconf-networking = "avahi-daemon avahi-utils libnss-mdns"
